EXTRA_OECONF:remove = "--with-libunistring-prefix=${STAGING_EXECPREFIXDIR}"
EXTRA_OECONF:append = " --with-included-libunistring"
